# Keil uVision project a.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51BH Intel
  cpu: IRAM(0-0x7F)  IROM(0-0xFFF) CLOCK(12000000)
  output: a +hex
  c flags: Optimize=8 SizeSpeed=1
  group group 1
    ./src/: adc.c i2c.c main.c oled.c adc.h i2c.h oled.h oledfont.h stc8g.h
